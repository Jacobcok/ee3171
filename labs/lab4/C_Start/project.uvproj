# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IROM(0x00000000,0x020000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: project
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5BB TARGET_IS_TM4C123_RA3
  c misc: --c99
  c include: ..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project.c startup_rvmdk.S
  group Libraries
    ./driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
